# IAR project obc_pinout.ewp, settings and files
configuration obc_pinout (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F405xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; E:\cubesat_firmware\ecss_services\services; E:\cubesat_firmware\ecss_services\platform\obc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: obc_pinout.hex
  ILINK.IlinkOutputFile: obc_pinout.out
  ILINK.IlinkIcfFile: stm32f405xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4XX/Source/TEMPLATES/iar/: startup_stm32f405xx.s
  group Application/User
    ../Src/: bsp_driver_sd.c fatfs.c freertos.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c
    ../Inc/: system.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4XX/Source/TEMPLATES/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4XX_HAL_DRIVER/Src/: stm32f4xx_hal.c stm32f4xx_hal_uart.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../MIDDLEWARES/THIRD_PARTY/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../MIDDLEWARES/THIRD_PARTY/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: portasm.s
    ../MIDDLEWARES/THIRD_PARTY/FreeRTOS/Source/: tasks.c
  group OBC
    ../../../../ecss_services/platform/obc/: housekeeping.c housekeeping.h obc.c obc.h power_ctrl.c power_ctrl.h
    ../../../../ecss_services/platform/obc/hal/stm32/: obc_hal.c obc_hal.h
  group Services
    ../../../../ecss_services/services/: event_reporting_service.c event_reporting_service.h function_management_service.c function_management_service.h hldlc.c hldlc.h housekeeping_service.c housekeeping_service.h large_data_service.c large_data_service.h mass_storage_service.c mass_storage_service.h pkt_pool.c pkt_pool.h scheduling_service.c scheduling_service.h service_utilities.c service_utilities.h services.c services.h su_mnlp.c su_mnlp.h test_service.c test_service.h time_management.c time_management.h verification_service.c verification_service.h
